# IAR project HIR.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F169 MSP430F169
  General.GStackSize2: 200
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f169.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430ff.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: ad.cpp Ad.H AD421.cpp AD421.h Alarm.c Alarm.h CurveFitting.c CurveFitting.H delay.cpp delay.h Device.H Dis_lib.h DisDataCalculate.c DisDataCalculate.H DS18B20.c DS18B20.h FittingData.H Flash_RW.cpp Flash_RW.H hart.c Hart.h HT1621.cpp HT1621.H KEYBOARD.cpp KEYBOARD.H Limited.H main.c MessageCenter.cpp MessageCenter.H Pwm.c Pwm.h RunAuto.c RunAuto.h RunConfig.c RunConfig.H RunMen.c RunMen.H Tick.cpp Tick.H Uart.c Uart.h
